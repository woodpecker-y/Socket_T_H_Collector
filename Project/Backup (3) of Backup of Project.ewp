# IAR project Backup (3) of Backup of Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_DBG; HAVE_BC95; HAVE_SHT3x; HAVE_TEST; HAVE_CU
  ICCSTM8.CCIncludePath2: ..\User\inc; ..\Board\; ..\Lib\include\bsp\; ..\Lib\include\hal\; ..\Lib\include\Libraries\; ..\Lib\include\; ..\Lib\include\Module\; ..\Lib\include\Utili\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BA2804-EV.hex
  ILINK.IlinkOutputFile: TempCollector.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\Lib\ADF.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LED; HAVE_LCD; HAVE_RFID; HAVE_KEY; HAVE_BEEP; HAVE_ADC; HAVE_LED; HAVE_RFID; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_CHIPVERIFY; HAVE_SHT3x; HAVE_BC95
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: V5-505.hex
  ILINK.IlinkOutputFile: Project.out
configuration LIGHT_DEBUG (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LED; HAVE_RFID; HAVE_KEY; HAVE_BEEP; HAVE_ADC; HAVE_LED; HAVE_LCD; HAVE_RFID; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_CHIPVERIFY; HAVE_DBG; HAVE_BC95; HAVE_TEST; HAVE_SHT3x; HAVE_CU; LIGHT_DEBUG
configuration CT (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_SHT3x; HAVE_BC95; HAVE_CT
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CT.hex
  ILINK.IlinkOutputFile: Project.out
configuration CU (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_SHT3x; HAVE_BC95; HAVE_CU
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CU.hex
  ILINK.IlinkOutputFile: Project.out
configuration CU_20Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_SHT3x; HAVE_BC95; HAVE_CU; HAVE_20MIN
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CU-20Min.hex
  ILINK.IlinkOutputFile: Project.out
configuration CU_Debug (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_ADC; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_BC95; HAVE_CU; HAVE_20MIN
configuration CT_20Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_BC95; HAVE_CT; HAVE_20MIN
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CT-20Min.hex
  ILINK.IlinkOutputFile: Project.out
configuration CU_3Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_BC95; HAVE_CU; HAVE_3MIN
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CT-20Min.hex
  ILINK.IlinkOutputFile: Project.out
configuration CT_3Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EXTI; HAVE_ADC; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_LED; HAVE_KEY; HAVE_LCD; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_BC95; HAVE_CT; HAVE_3MIN
  ICCSTM8.CCDiagSuppress: Pa050
  OBJCOPY.OOCOutputFile: T3-CT-20Min.hex
  ILINK.IlinkOutputFile: Project.out
  group Board
    ../Board/: board.c board.h
  group Docs
    ../: CHANGELOG.md
  group Lib
    ../Lib/: ADF.a
  group User
    ../User/src/: bc95.c disp.c error.c light.c log_data.c main.c protocol.c sht3x.c stm8l15x_it.c sysparams.c task_disp.c task_key.c task_main.c task_report.c task_sample.c task_super_capacitor.c update_cycle.c
