# IAR project Backup of Backup of Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; USE_FULL_ASSERT; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LED; HAVE_DBG; HAVE_RFID; HAVE_KEY; HAVE_BEEP; HAVE_ADC; HAVE_LED; HAVE_RFID; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_CHIPVERIFY
  ICCSTM8.CCIncludePath2: ..\User\inc; ..\Board\; ..\Lib\include\bsp\; ..\Lib\include\hal\; ..\Lib\include\Libraries\; ..\Lib\include\; ..\Lib\include\Module\; ..\Lib\include\Utili\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BA2804-EV.hex
  ILINK.IlinkOutputFile: TempCollector.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\Lib\ADF.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; USE_FULL_ASSERT; HAVE_COM; HAVE_EXTI; HAVE_RF; HAVE_ADC; HAVE_ALARM; HAVE_EEPROM; HAVE_CHIPVERIFY; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_MOTOR; HAVE_LED; HAVE_RFID; HAVE_KEY; HAVE_BEEP; HAVE_ADC; HAVE_LED; HAVE_RFID; HAVE_ENCRYPT; HAVE_SYSTIMER; HAVE_CHIPVERIFY
  OBJCOPY.OOCOutputFile: V5.hex
  ILINK.IlinkOutputFile: Project.out
  group Board
    ../Board/: board.c board.h
  group Docs
    ../Docs/: README.txt
  group Lib
    ../Lib/: ADF.a
  group User
    ../User/src/: cj188.c error.c main.c modbus.c protocol.c stm8l15x_it.c sysparams.c task_adc.c task_beep.c task_comm.c task_key.c task_led.c task_main.c task_motor.c task_one_week_rotation.c task_reader.c verify.c
