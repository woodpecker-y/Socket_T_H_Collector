<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\Board\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Board\board.h</name>
    </file>
  </group>
  <group>
    <name>Docs</name>
    <file>
      <name>$PROJ_DIR$\..\Docs\README.txt</name>
    </file>
  </group>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\..\Lib\ADF.a</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\src\cj188.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\modbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\sysparams.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_comm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_one_week_rotation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\task_reader.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\src\verify.c</name>
    </file>
  </group>
</project>


