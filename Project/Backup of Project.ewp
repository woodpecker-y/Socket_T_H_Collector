# IAR project Backup of Project.ewp, settings and files
configuration CT_BC95_20Min (STM8)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_SYSTIMER; HAVE_NB; HAVE_CT; HAVE_BC95; HAVE_20MIN
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\User\inc; ..\Board\; ..\Lib\include\bsp\; ..\Lib\include\hal\; ..\Lib\include\Libraries\; ..\Lib\include\; ..\Lib\include\Module\; ..\Lib\include\Utili\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ChaZhuo-BC95-CT.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CU_ML5515_20Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_SYSTIMER; HAVE_NB; HAVE_CU; HAVE_ML5515; HAVE_20MIN
  OBJCOPY.OOCOutputFile: ChaZhuo-ML5515-CU.hex
configuration CT_ML5515_20Min (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; HAVE_COM; HAVE_EEPROM; HAVE_RTC; HAVE_WDG; HAVE_AWU; HAVE_UID; HAVE_SYSTIMER; HAVE_NB; HAVE_CT; HAVE_AES128_ECB_PKCS7PADDING; HAVE_ML5515; HAVE_20MIN
  OBJCOPY.OOCOutputFile: ChaZhuo-ML5515-CT.hex
  group Board
    ../Board/: board.c board.h
    ../User/inc/: sysparams.h
  group Docs
    ../: CHANGELOG.md
  group Lib
    ../Lib/: ADF.a
  group User
    ../User/src/: AdcDriver.c aes.c error.c LCD.c log_data.c main.c nb.c protocol.c sht3x.c stm8l15x_it.c sysparams.c task_disp.c task_main.c task_pwm.c task_report.c task_sample.c update_cycle.c
